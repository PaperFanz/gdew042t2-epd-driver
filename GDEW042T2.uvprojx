# Keil uVision project GDEW042T2.uvprojx, settings and files
target GDEW042T2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gdew042t2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c gdew042t2.c epdgl.c font.c fifo.c keypad.c easi.c easi_globals.c gui.c keymap.c bar.c voltmeter.c rpn.c AlphaValues.c ExpressionTree.c Math.c alg.h alg.c
    ../inc/: PLL.c LaunchPad.c Timer0A.c Timer1A.c CortexM.c Timer2A.c
software components: CMSIS:CORE 5.0.2
